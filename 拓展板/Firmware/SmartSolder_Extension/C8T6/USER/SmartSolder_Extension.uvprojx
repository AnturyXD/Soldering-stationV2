# Keil uVision project SmartSolder_Extension.uvprojx, settings and files
target SmartSolder_Extension (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SmartSolder_Extension +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM;..\SYSTEM\delay;..\SYSTEM\timer;..\SYSTEM\debug_uart;..\SYSTEM\esp_uart;..\SYSTEM\lower_uart;..\HARDWARE\BOARD;..\HARDWARE\RELAY;..\HARDWARE\PRESENCE;..\HARDWARE\ESP01S;..\HARDWARE\LOWER_LINK;..\HARDWARE\ST7789;..\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: startup_stm32f10x_md.s core_cm3.c
  group APP
    ../APP/: app_state.c display_ui.c ui_assets.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/timer/: timer.c
    ../SYSTEM/debug_uart/: debug_uart.c
    ../SYSTEM/esp_uart/: esp_uart.c
    ../SYSTEM/lower_uart/: lower_uart.c
    ../SYSTEM/: sys.c
  group HARDWARE
    ../HARDWARE/BOARD/: board_io.c
    ../HARDWARE/RELAY/: relay.c
    ../HARDWARE/PRESENCE/: presence.c
    ../HARDWARE/ESP01S/: esp01s.c
    ../HARDWARE/LOWER_LINK/: lower_link.c
    ../HARDWARE/ST7789/: st7789.c
  group STM32F10x_FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_spi.c
